## boards/shields/blaster_pad/Kconfig.defconfig
```kconfig
if SHIELD_BLASTER_PAD

config ZMK_KEYBOARD_NAME
    default "Blaster_Pad"

endif
```
